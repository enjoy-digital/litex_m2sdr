options:
  parameters:
    author: gwe
    generate_options: qt_gui
    id: test_tx_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freqRX
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433e6
  states: {}
- name: freqTX
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433e6
  states: {}
- name: gainRx
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(73)
    value: int(6)
  states: {}
- name: attTX
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(89)
    value: int(89)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      TX1 must be connected to RX1

      - sink and source are configured with the same default freq
      - sink receive a constant value: only carrier frequency is visible
      - by playing with freqRX/freqTx sliders carrier will moved
      - attTX sets TX attenuation in positive dB
      - reducing attTX or increasing gainRX will increase received carrier amplitude
    note: TX -> RX ext loopback
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    plotconst: 'False'
    type: complex
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    antenna0: A
    bandwidth0: 10e6
    center_freq0: freqTX
    driver: LiteXM2SDR
    gain0: attTX
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    antenna1: A_BALANCED
    bandwidth0: 10e6
    bandwidth1: 10e6
    center_freq0: freqRX
    center_freq1: freqRX
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: bypass_init=0
    driver: LiteXM2SDR
    gain0: gainRx
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', soapy_custom_sink_0, '0']
- [soapy_custom_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
