options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: frequency_carrier
  id: variable
  parameters:
    value: 5825e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2 * bandwidth
  states: {}
- name: NTSC_decoder_c_0
  id: NTSC_decoder_c
  parameters:
    samp_rate: samp_rate
  states: {}
- name: NTSC_video_stream_converter_c_0
  id: NTSC_video_stream_converter_c
  parameters:
    decimation_factor: samp_rate / (360 *240 * 60)
    samp_rate: samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*850000000/8.0)
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e6
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      | FR   |  CH1  |  CH2  |  CH3  |  CH4  |  CH5  |  CH6  |  CH7  |  CH8  |
      | ----- | ------- | ------- | ------- | ------- | ------- | ------- | ------- | ------- |
      | FR1 | 5865 | 5845 | 5825 | 5805 | 5785 | 5765 | 5745 | 5725 |
      | FR2 | 5733 | 5752 | 5771 | 5790 | 5809 | 5828 | 5847 | 5866 |
      | FR3 | 5705 | 5685 | 5665 | 5645 | 5885 | 5905 | 5925 | 5945 |
      | FR4 | 5740 | 5760 | 5780 | 5800 | 5820 | 5840 | 5860 | 5880 |
      | FR5 | 5658 | 5695 | 5732 | 5769 | 5806 | 5843 | 5880 | 5917 |
    note: Frequency Carrier Table
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    antenna1: A_BALANCED
    bandwidth0: bandwidth
    bandwidth1: 10e6
    center_freq0: frequency_carrier
    center_freq1: 5.825e9
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: bypass_init=0
    driver: LiteXM2SDR
    gain0: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: 240 * 2
    display_width: 360 * 2
    fps: '0'
    height: '240'
    type: short
    width: '360'
  states: {}

connections:
- [NTSC_decoder_c_0, '0', NTSC_video_stream_converter_c_0, '0']
- [NTSC_decoder_c_0, '1', NTSC_video_stream_converter_c_0, '1']
- [NTSC_decoder_c_0, '2', NTSC_video_stream_converter_c_0, '2']
- [NTSC_decoder_c_0, '3', NTSC_video_stream_converter_c_0, '3']
- [NTSC_video_stream_converter_c_0, '0', video_sdl_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', NTSC_decoder_c_0, '0']
- [soapy_custom_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
