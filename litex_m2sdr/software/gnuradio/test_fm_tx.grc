options:
  parameters:
    author: enjoy-digital
    generate_options: qt_gui
    id: test_fm_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.5e6
    step: 50e3
    stop: 108e6
    value: 97.4e6
  states: {}
- name: att
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(89)
    value: int(10)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(8e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    center_freq0: freq
    dev_args: bypass_init=0
    driver: LiteXM2SDR
    gain0: att
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', soapy_custom_sink_0, '0']

metadata:
  file_format: 1
