options:
  parameters:
    author: gwe
    generate_options: qt_gui
    id: test_tx_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freqTX
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433e6
  states: {}
- name: attTX
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(89)
    value: int(89)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/dataTx.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      Both Tx receives same signal

      - with constant source only the carrier is visible
      - with signal source a 1MHz cosine is mixed to carrier
      - with file source an arbitrary complex signal is produces
      (Uses 'D' to disable and 'E' to enable a source)

      - freqTx slider is used to change center frequency
      - attTX slider sets TX attenuation in positive dB
      - lower attenuation increases TX output power
    note: Dual Channels TX test
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    antenna0: A
    antenna1: A
    bandwidth0: 10e6
    bandwidth1: 10e6
    center_freq0: freqTX
    center_freq1: freqTX
    driver: LiteXM2SDR
    gain0: attTX
    gain1: attTX
    nchan: '2'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_const_source_x_0, '0', soapy_custom_sink_0, '0']
- [analog_const_source_x_0, '0', soapy_custom_sink_0, '1']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [analog_sig_source_x_0, '0', soapy_custom_sink_0, '0']
- [analog_sig_source_x_0, '0', soapy_custom_sink_0, '1']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', soapy_custom_sink_0, '0']
- [blocks_file_source_0, '0', soapy_custom_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
