options:
  parameters:
    author: gwe
    generate_options: no_gui
    id: test_fm_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.5e6
    step: 50e3
    stop: 108e6
    value: 97.4e6
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 102.4e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(73)
    value: int(6)
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100e-3'
    stop: '1'
    value: '500e-3'
  states: {state: disabled}
- name: volume
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: samp_rate/25
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/125*6/5)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /tmp/audio.wav
    format: FORMAT_WAV
    samp_rate: int(samp_rate/125*6/5)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/50
    decim: '25'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/128
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      5MS/s -> /25 (low pass filter): 200kS/s
      WBFM Receive: 200 M / 5 = 40 kS/s
      Rational Resampler: 40e3/5*6=48kHz
    note: FM Radio test.
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '6'
    type: fff
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    antenna1: A_BALANCED
    bandwidth0: 8e6
    bandwidth1: 20e6
    center_freq0: freq
    center_freq1: freq
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: bypass_init=0
    driver: LiteXM2SDR
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']
- [soapy_custom_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
