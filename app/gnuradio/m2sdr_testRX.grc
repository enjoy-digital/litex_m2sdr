options:
  parameters:
    generate_options: no_gui
    id: m2sdr_testRX
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 30720000.0/4
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/toto.bin
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 65536*4
    type: complex
  states: {}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    bandwidth0: 20e6
    center_freq0: 100e6
    dc_removal0: 'False'
    driver: LiteXM2SDR
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [soapy_custom_source_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
