options:
  parameters:
    generate_options: qt_gui
    id: m2sdr_test_rx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: freqRX
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433e6
  states: {}
- name: gainRx
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(73)
    value: int(6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/m2sdr_chanA.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/m2sdr_chanB.bin
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      - center Frequency may be changed using  freqRX slider
      - gain may be increased/decreased by using gainTX slider
      - both channel are displayed
      - each channel stream is stored in a specific file (/tmp/m2sdr_chanA.bin, /tmp/m2sdr_chanB.bin)
    note: RX receiver
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RXA"'
    plotconst: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RXB"'
    plotconst: 'False'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    antenna1: A_BALANCED
    bandwidth0: 10e6
    bandwidth1: 10e6
    center_freq0: freqRX
    center_freq1: freqRX
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: bypass_init=0
    driver: LiteXM2SDR
    gain0: gainRx
    nchan: '2'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', blocks_file_sink_0, '0']
- [soapy_custom_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_custom_source_0, '1', blocks_file_sink_0_0, '0']
- [soapy_custom_source_0, '1', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
