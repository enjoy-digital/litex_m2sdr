options:
  parameters:
    author: gwe
    generate_options: qt_gui
    id: xtrx_fm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 50e3
    stop: 500e6
    value: 433.9e6
  states: {}
- name: gainA
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(73)
    value: int(6)
  states: {}
- name: gainB
  id: variable_qtgui_range
  parameters:
    start: int(0)
    step: int(1)
    stop: int(73)
    value: int(6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(16e6)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100e-3'
    stop: '1'
    value: '500e-3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '16'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label: Relative Gain v2
    name: '"v2"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: A_BALANCED
    antenna1: A_BALANCED
    bandwidth0: 20e6
    bandwidth1: 20e6
    center_freq0: freq
    center_freq1: freq
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: bypass_init=1
    driver: LiteXM2SDR
    gain0: gainA
    gain1: gainB
    nchan: '2'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_custom_source_0, '0', low_pass_filter_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_custom_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [soapy_custom_source_0, '1', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
